# Keil uVision project XiaoMi_F103.uvprojx, settings and files
target XiaoMi_F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XiaoMi_F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Core\hooch_protocol;..\Core\hooch_protocol\protocol_common;..\Core\hooch_protocol\hooch_auto_task;..\Core\hooch_protocol\tuya_protocol\mcu_sdk;..\Core\hooch_protocol\knx_protocol;..\Core\hooch_protocol\xiaomi_smart_screen;..\Core\hooch_protocol\hf_zxk_modbus_protocol;..\Core\hooch_protocol\hf_zjk_modbus_protocol
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c log_example.c user_printf.c hooch_cli_driver.c system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group hooch
    ../Core/hooch_protocol/protocol_common/: hooch_protocol_common.c
    ../Core/hooch_protocol/: hooch_dimmer_light_dispatch.c hooch_dimmer_light_report.c hooch_floor_heating_dispatch.c hooch_floor_heating_report.c hooch_fresh_air_dispatch.c hooch_fresh_air_report.c hooch_key_click_report.c hooch_key_name.c hooch_key_status_dispatch.c hooch_key_status_report.c hooch_page_adjust.c hooch_protocol_input.c hooch_protocol_output.c hooch_scene_dispatch.c hooch_scene_report.c hooch_setting.c hooch_setting_report.c hooch_key_mode.c hooch_air_conditioner_dispatch.c hooch_air_conditioner_report.c hooch_curtain_dispatch.c hooch_curtain_report.c hooch_code_match_dispatch_dispatch.c hooch_code_match_dispatch_report.c
  group tuya
    ../Core/hooch_protocol/tuya_protocol/mcu_sdk/: mcu_api.c protocol.c system.c tuya_report_callbacks.c tuya_basic_setting.c tuya_device_air.c tuya_device_floor.c tuya_device_freshair.c tuya_device_key.c tuya_device_scene.c tuya_device_switch.c
  group knx
    ../Core/hooch_protocol/knx_protocol/: knx_basic_function.c knx_basic_setting.c knx_circular_buffer.c knx_device_air.c knx_device_curtain.c knx_device_dimming.c knx_device_floor_heating.c knx_device_fresh_air.c knx_device_key.c knx_handle.c knx_device_scene.c
  group xiaomi_v1
    ../Core/hooch_protocol/xiaomi_smart_screen/: xiaomi_smart_screen_circular_buffer.c xiaomi_smart_screen_handle.c
  group hf_zxk_modbus
    ../Core/hooch_protocol/hf_zxk_modbus_protocol/: hf_zxk_modbus_circular_buffer.c hf_zxk_modbus_handle.c
  group hf_zjk_modbus
    ../Core/hooch_protocol/hf_zjk_modbus_protocol/: hf_zjk_modbus_circular_buffer.c hf_zjk_modbus_handle.c
software components: CMSIS:CORE 5.6.0
